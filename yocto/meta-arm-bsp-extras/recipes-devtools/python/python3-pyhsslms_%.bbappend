#
# SPDX-FileCopyrightText: <text>Copyright 2024 Arm Limited and/or its
# affiliates <open-source-office@arm.com></text>
#
# SPDX-License-Identifier: MIT

# oelint-adv does not support interpolated include paths
# nooelint: oelint.file.includenotfound
include python3-pyhsslms-${MACHINE}.inc
