#
# SPDX-FileCopyrightText: <text>Copyright 2023-2024 Arm Limited and/or its
# affiliates <open-source-office@arm.com></text>
#
# SPDX-License-Identifier: MIT

require recipes-security/optee/optee-os.inc

DEPENDS += "dtc-native"

SRCREV = "001ace6655dd6bb9cbe31aa31b4ba69746e1a1d9"
