#
# SPDX-FileCopyrightText: <text>Copyright 2024 Arm Limited and/or its
# affiliates <open-source-office@arm.com></text>
#
# SPDX-License-Identifier: MIT

ARM_TSTEE_REQUIRE ?= ""
ARM_TSTEE_REQUIRE:baremetal = "arm-tstee-arm-auto-solutions.inc"
require ${ARM_TSTEE_REQUIRE}
